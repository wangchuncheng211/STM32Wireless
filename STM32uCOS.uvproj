# Keil uVision project STM32uCOS.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32uCOS
  c flags: Optim=1
  c include: .\APP;.\BSP;.\CM3;.\FWlib\inc;.\uCGUI\uCGUIConfig;.\uCGUI\uCGUIInc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./APP/: app.c stm32f10x_it.c Fun.c
  group BSP
    ./BSP/: bsp.c NRF24L01.c
  group BSP/TFT
    ./BSP/TFT/: fsmc_sram.c lcdrv.c lcd.c lcd_ucgui.c lcd_api.c lcd_touch.c
  group CM3
    ./CM3/: system_stm32f10x.c core_cm3.c
  group FWLib
    ./FWlib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_fsmc.c
  group Startup
    ./Startup/: stm32f10x_startup.s
  group uCOS/Source
    ./uCOS-II/Source/: os_core.c os_mbox.c os_sem.c os_task.c os_time.c
  group uCOS/Port
    ./uCOS-II/Ports/: os_cpu_c.c os_cpu_a.asm
  group uCOS/CPU
    ./uCOS-II/uC-CPU/: cpu_a.asm
  group uCOS_GUI_X
    ./uCOS-IIGUI_X/: GUI_X_Touch.c GUI_X_uCOS.c
  group uCGUI/Config
    ./uCGUI/uCGUIConfig/: GUIConf.h GUITouchConf.h LCDConf.h
  group uCGUI/Inc
    ./uCGUI/uCGUIInc/: BUTTON.h BUTTON_Private.h CHECKBOX.h CHECKBOX_Private.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h GUI.h GUI_ARRAY.h GUI_ConfDefaults.h GUI_FontIntern.h GUI_HOOK.h GUI_Private.h GUI_Protected.h GUI_VNC.h GUI_X.h GUIDebug.h GUIType.h GUIVersion.h HEADER.h HEADER_Private.h jconfig.h jdct.h jdhuff.h jerror.h jinclude.h jmemsys.h jmorecfg.h jpegint.h jpeglib.h jversion.h LCD.h LCD_ConfDefaults.h LCD_IncludeDriver.h LCD_Private.h LCD_Protected.h LCDSIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h TEXT.h TEXT_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h WM_Intern_ConfDep.h
  group uCGUI/Lib
    ./uCGUI/uCGUILib/: uCGUI_DEMO.lib
